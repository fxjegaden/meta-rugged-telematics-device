PRETTY_NAME = "${DISTRO_NAME} ${VERSION} - iW-PRGST-SC-R1.0-REL2.5.1_RTD_Root_FileSystem"
