require stimio-bundle.inc
RAUC_SLOT_rootfs ?= "core-image-minimal"
