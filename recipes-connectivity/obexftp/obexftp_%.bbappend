FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://BT_FTP_support_iwg26i.patch"
